*
Vin	Vin	0	AC	1
*
R9	vin	1	100
R10	1	2	33k
R11	2	3	33k
C15	1	3	0.001
C13	1	4	0.1u
P	4	0	1	100k
C14	2	4	0.047u
C16	3	5	0.22u
R12	5	6	100k
C17	6	vout	0.001u
R13	6	vout	100k
*
*	V-	V+	out
Z2b	6	0	vout
